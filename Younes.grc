options:
  parameters:
    author: Younes Jose
    generate_options: qt_gui
    id: Younes
    output_language: python
    title: Ejemplo Actividad 1
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: round((samp_rate/2)/(100e3))
  states: {}
- name: freq_canal
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sintonia fina
    start: '-5e6'
    step: 10e3
    stop: 5e6
    value: '0'
  states: {}
- name: freq_sdr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Sintonia gruesa
    start: (88+5)*1e6
    step: 5e6
    stop: (109-5)*1e6
    value: (88+5)*1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10*1000*1000
  states: {}
- name: samp_rate_decim
  id: variable
  parameters:
    value: samp_rate/decim
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_canal
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '5'
    deemph_tau: '75e-6'
    quad_rate: samp_rate_decim
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq_sdr
    freq_span: samp_rate
    gui_hint: 'tabs@0: 0,0,1,1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: round(5/.1)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@2: 0,0,1,1'
    name: '"Audio"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_decim
    fc: freq_sdr+freq_canal
    fftsize: '1024'
    gui_hint: 'tabs@1: 0,0,1,1'
    int_max: '0'
    name: '"Canal"'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: freq_sdr
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,10,1
    label0: RF
    label1: Canal
    label2: Audio
    num_tabs: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_pll_0, '0', qtgui_time_sink_x_0, '0']
- [analog_wfm_rcv_pll_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_correctiq_0, '0', blocks_multiply_xx_0, '0']
- [blocks_correctiq_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
